Commit message: Finalising Fire

File: assets_new/fire/fire.urdf (robot description, URDF)
Before this commit: robot fire, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=fire.obj scale=0 0 0; visual mesh filename=fire.obj scale=1 1 1
